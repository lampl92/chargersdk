# Keil uVision project chargersdk.uvproj, settings and files
target debug (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F429IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: chargersdk
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: OS_SUPPORT,USE_HAL_DRIVER,STM32F429xx,DEBUG
  c include: ..\..\src\drivers\hal\CMSIS\Include;..\..\src\drivers\hal\CMSIS_RTOS;..\..\src\drivers\hal\CMSIS\Device\ST\STM32F4xx\Include;..\..\src\drivers\hal\STM32F4xx_HAL_Driver\Inc;..\..\src\os\FreeRTOS\Source\include;..\..\src\os\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\src\os;..\..\src\drivers\bsp\inc;..\..\src\app;..\..\src\cli;..\..\src\middlewares\tinysh;..\..\src\middlewares\STemWin\inc;..\..\src\middlewares\STemWin\Config;..\..\src\middlewares\STemWin\Demo;..\..\src\middlewares\fatfs\src;..\..\src\middlewares\fatfs\diskdrv;..\..\src\middlewares\sqlite;..\..\src\middlewares\ezxml
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ../../src/app/: main.c stm32f4xx_it.c stm32f4xx_it.h apptask.c sysinit.c
  group cli
    ../../src/cli/: cli_main.c cli_app.c cli_rtos.c cli_fatfs.c
  group emwin\config
    ../../src/middlewares/STemWin/Config/: GUIConf.c GUIConf.h LCDConf_Lin_ATK_7016.c LCDConf.h
  group emwin\gui_x
    ../../src/middlewares/STemWin/GUI_X/: GUI_X_FreeRTOS.c GUI_X_OS.c
  group emwin\lib
    ../../src/middlewares/STemWin/Lib/: STemWin532_CM4_OS_Keil.lib
  group drivers\bsp
    ../../src/drivers/bsp/inc/: bsp.h
    ../../src/drivers/bsp/src/: bsp.c bsp_uart.c bsp_sdram.c bsp_dwt.c malloc.c bsp_rtc.c bsp_user_lib.c bsp_nand_ftl.c bsp_nand_hw.c
  group drivers\device
    ../../src/drivers/device/src/: lcd_ATK7016.c
  group drivers\hal\cmsis\startup
    ../../src/drivers/hal/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../../src/drivers/hal/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429xx.s
  group drivers\hal\cmsis-rtos
    ../../src/drivers/hal/CMSIS_RTOS/: cmsis_os.c
  group drivers\hal\STM32F4xx_HAL_Driver
    ../../src/drivers/hal/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal_conf.h
    ../../src/drivers/hal/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_dma.c stm32f4xx_hal_sdram.c stm32f4xx_ll_fmc.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_nand.c
  group freertos\source
    ../../src/os/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group freertos\portable
    ../../src/os/: FreeRTOSConfig.h
    ../../src/os/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../src/os/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group middlewares\lua
    ../../src/middlewares/lua/src/: lapi.c lauxlib.c lbaselib.c lbitlib.c lcode.c lcorolib.c lctype.c ldblib.c ldebug.c ldo.c ldump.c lfunc.c lgc.c linit.c liolib.c llex.c lmathlib.c lmem.c loadlib.c lobject.c lopcodes.c loslib.c lparser.c lstate.c lstring.c lstrlib.c ltable.c ltablib.c ltm.c lundump.c lutf8lib.c lvm.c lzio.c
  group middlewares\tinysh
    ../../src/middlewares/tinysh/: tinysh.c
  group middlewares\fatfs
    ../../src/middlewares/fatfs/src/: diskio.c ff.c
    ../../src/middlewares/fatfs/src/option/: cc936.c
    ../../src/middlewares/fatfs/diskdrv/: ff_gen_drv.c nand_diskio.c
  group middlewares\sqlite
    ../../src/middlewares/sqlite/: shell.c sqlite3.c
  group middlewares\ezxml
    ../../src/middlewares/ezxml/: ezxml.c
  group emwin\demo
    ../../src/middlewares/STemWin/Demo/: GUIDEMO.c GUIDEMO_Start.c
